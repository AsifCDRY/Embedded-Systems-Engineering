# Keil uVision project MediaCentre.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MediaCentre +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\DMA.sct
  group Main Menu
    ./: Main_Menu.c Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c
  group Photo Gallery
    ./: Photo_Gallery.c picture1.c picture2.c picture3.c picture4.c
  group Game
    ./: PACMAN.h PACMAN.c Game.c PACMAN_OPENWORLD.c
  group MP3 Player
    ./: MP3_Player.c adcuser.c core_cm3.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c
software components: CMSIS:CORE 5.4.0, Board Support:A/D Converter 1.0.0, Board Support:Joystick 1.0.0, Board Support:LED 1.0.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
